## Kconfig
```kconfig
config GQB_HELLO
	tristate "TQ2416 gqb_hello"
	help
	   gqb's first driver program!
```
